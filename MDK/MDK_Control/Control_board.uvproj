# Keil uVision project Control_board.uvproj, settings and files
target Control_board (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Control
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,CONTROL_MAIN_BOARD
  c include: ..\..\APP;..\..\BSP;..\..\BSP\hal;..\..\Hilscher_Toolkit\Source;..\..\Hilscher_Toolkit\User;..\..\ST\CMSIS\Include;..\..\ST\STM32F2xx_StdPeriph_Driver\inc;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\USER;..\..\uCOS-II\Source;..\..\USER\IAP;..\..\Hilscher_Toolkit\OSAbstraction;..\..\FATFS\src;..\..\ST\CMSIS\Device\ST\STM32F2xx\Include;..\..\APP\control_board;..\..\APP\slave_board1;..\..\APP\slave_board2;..\..\APP\slave_board3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../../APP/: app.c app_shell.c app_usart_dma_route.c app_led.c app_can.c app_fs.c app_user_tmr.c app_buzzer_ring.c app_trouble_shooting.c
    ../../APP/control_board/: app_cmd_analysis.c app_control_board.c app_control_pdo_callback.c app_control_flow.c app_control_monitor.c app_comX100.c app_control_adjust_implement.c app_control_common_function.c app_control_timing_back.c app_cmd_send.c app_control_pump.c app_control_key_press.c app_control_poweron_test.c app_control_speed_table.c app_control_blood_collect.c app_control_set_canal.c app_control_global_state.c app_control_feedback.c app_control_cali_pump.c
  group USER
    ../../USER/: common.c main.c shell.c stm32f2xx_it.c trace.c
  group BSP
    ../../BSP/: bsp.c
    ../../BSP/hal/: can.c comx100.c gpio.c usart.c watchdog.c delay.c spi.c spi_flash.c sram.c rtc.c bell.c
  group StdLib
    ../../ST/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_usart.c stm32f2xx_wwdg.c stm32f2xx_rcc.c stm32f2xx_iwdg.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_spi.c stm32f2xx_dma.c stm32f2xx_rtc.c stm32f2xx_pwr.c stm32f2xx_adc.c
  group Hilscher_Toolkit
    ../../Hilscher_Toolkit/Source/: cifXDownload.c cifXEndianess.c cifXFunctions.c cifXHWFunctions.c cifXInit.c cifXInterrupt.c md5.c
    ../../Hilscher_Toolkit/User/: TKitUser_Custom.c
    ../../Hilscher_Toolkit/OSAbstraction/: OS_Custom.c
  group FATFS
    ../../FATFS/src/: ff.c diskio.c
  group uCOS-II/source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/ports
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group CMSIS
    ../../ST/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ../../ST/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
