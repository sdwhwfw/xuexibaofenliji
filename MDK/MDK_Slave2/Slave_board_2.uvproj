# Keil uVision project Slave_board_2.uvproj, settings and files
target Slave_board_2 (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: NETX
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,SLAVE_BOARD_2
  c include: ..\..\APP;..\..\BSP;..\..\BSP\hal;..\..\uCOS-II\Source;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\USER;..\..\USER\IAP;..\..\USER\test_program;..\..\ST\STM32F2xx_StdPeriph_Driver\inc;..\..\ST\CMSIS\Include;..\..\ST\CMSIS\Device\ST\STM32F2xx\Include;..\..\APP\slave_board2;..\..\APP\slave_board1;..\..\APP\slave_board3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../../APP/: app.c app_shell.c app_modbus_analyse.c app_usart_dma_route.c app_led.c app_task_err.c app_buzzer_ring.c app_user_tmr.c app_watchdog.c app_dc_motor.c
    ../../APP/slave_board2/: app_pump_control2.c app_slave_board2.c app_monitor2.c app_pdo_callback2.c app_sensor_handle2.c struct_slave_board2.c app_sensor_board2.c app_da_output.c app_valve_control.c
  group USER
    ../../USER/: main.c queue.c shell.c stm32f2xx_it.c crc.c trace.c datafilter_variance.c pid.c protocol.c
  group BSP
    ../../BSP/: bsp.c
    ../../BSP/hal/: delay.c gpio.c usart.c watchdog.c basic_timer.c bell.c encoder.c pwm.c adc_dac.c exti_board2.c flash_if.c
  group StdLib
    ../../ST/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c stm32f2xx_dma.c stm32f2xx_adc.c stm32f2xx_dac.c stm32f2xx_flash.c stm32f2xx_crc.c
  group uCOS-II/source
    ../../uCOS-II/Source/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_core.c
  group uCOS-II/ports
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group CMSIS
    ../../ST/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ../../ST/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
